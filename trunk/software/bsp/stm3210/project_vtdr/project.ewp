# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\Libraries\CMSIS\CM3\CoreSupport; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\libcpu\arm\stm32; ..\..\..\finsh; ..\..\..\filesystem\dfs\; ..\..\..\filesystem\dfs\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: .; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\CMSIS\Core\CM3; ..\..\include; ..\..\libcpu\arm\stm32
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../LIBRARIES/CMSIS/CM3/CORESUPPORT/: core_cm3.c
    ../LIBRARIES/CMSIS/CM3/DEVICESUPPORT/ST/STM32F10X/: system_stm32f10x.c
  group Filesystem
    ../../../filesystem/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../filesystem/dfs/src/: dfs_fs.c dfs_init.c dfs_raw.c dfs_util.c
    ../../../FILESYSTEM/dfs/src/: dfs_posix.c
  group finsh
    ../../../finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Kernel
    ../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group Startup
    ./: application.c board.c lcd.c led.c msd.c rtconfig.h sdcard.c startup.c stm32f10x_it.c usart.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_wwdg.c
    ../LIBRARIES/STM32F10X_STDPERIPH_DRIVER/src/: stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group STM32
    ../../../libcpu/arm/stm32/: context_iar.S cpu.c fault.c fault_iar.S interrupt.c serial.c stack.c start_iar.S
